## Config.in
```kconfig
config BR2_PACKAGE_NINVADERS
    bool "nInvaders"
    select BR2_PACKAGE_NCURSES
    help
      nInvaders is a game for ENSIBS
```
